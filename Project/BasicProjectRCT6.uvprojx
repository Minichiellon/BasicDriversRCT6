# Keil uVision project BasicProjectRCT6.uvprojx, settings and files
target STM32F103 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\User;..\System;..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\FWlib\inc;..\Libraries\FWlib\src;..\Test;..\Demo;..\bsp\bsp_Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group SYSTEM
    ../System/: system_f103.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp_Inc
    ../bsp/bsp_Inc/: bsp_24Cxx.h bsp_adc.h bsp_BH1750.h bsp_can.h bsp_DHT11.h bsp_DS18B20.h bsp_ESP8266.h bsp_IICSoft.h bsp_key.h bsp_lcd_2.8_ili93xx.h bsp_lcd_ili9341.h bsp_led.h bsp_pwm.h bsp_relay.h bsp_RS485.h bsp_RTC.h bsp_SR04.h bsp_syn6288.h bsp_tim.h bsp_usart.h bsp_W25Q128.h bsp_w25qxx.h bsp_xpt2046.h dac.h diskio.h fattester.h ff.h ffconf.h font.h fontsa.h integer.h mallco.h servo.h TF.h ws2812.h bsp_IC.h bspInc_conf.h
  group bsp_Src
    ../bsp/bsp_Src/: bsp_can.c bsp_key.c bsp_led.c bsp_usart.c bsp_tim.c bsp_pwm.c bsp_IC.c bsp_OLED.c OLED_Data.c
  group Test
    ../Test/: test.c test.h
  group Demo
    ../Demo/: UsartCtlCan.c UsartCtlCan.h
  group USER
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h
